# Keil uVision project APP.uvprojx, settings and files
target APP (6220000::V6.22::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08011000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470
  c include: ..\CMSIS;..\CMSIS\m-profile;..\Library\Include;.\app;.\bsp;.\drivers;.\middleware;.\Objects;.\USER;..\shared;..\FreeRTOS\include;..\FreeRTOS\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8011000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group LIB
    ../Library/Source/: gd32f4xx_adc.c gd32f4xx_can.c gd32f4xx_crc.c gd32f4xx_ctc.c gd32f4xx_dac.c gd32f4xx_dbg.c gd32f4xx_dci.c gd32f4xx_dma.c gd32f4xx_enet.c gd32f4xx_exmc.c gd32f4xx_exti.c gd32f4xx_fmc.c gd32f4xx_fwdgt.c gd32f4xx_gpio.c gd32f4xx_i2c.c gd32f4xx_ipa.c gd32f4xx_iref.c gd32f4xx_misc.c gd32f4xx_pmu.c gd32f4xx_rcu.c gd32f4xx_rtc.c gd32f4xx_sdio.c gd32f4xx_spi.c gd32f4xx_syscfg.c gd32f4xx_timer.c gd32f4xx_tli.c gd32f4xx_trng.c gd32f4xx_usart.c gd32f4xx_wwdgt.c
  group CMSIS
    ../CMSIS/: system_gd32f4xx.c
  group FREERTOS
    ../FreeRTOS/: tasks.c queue.c list.c
    ../FreeRTOS/portable/GCC/ARM_CM4F/: port.c
    ../FreeRTOS/portable/MemMang/: heap_4.c
  group STARTUP
    ../Library/: startup_gd32f450_470.s
  group SHARED
    ../shared/: crc.c fmc.c param_store.c app_jump.c
  group BSP
    ./bsp/: bsp_tick.c bsp_uart.c bsp_led.c bsp_gpio.c bsp_key.c bsp_pinmap.h bsp_spi.c bsp_i2c.c bsp_adc.c bsp_timer.c bsp_rtc.c bsp_pmu.c bsp_irq_prio.c bsp_dac.c
  group DRIVERS
    ./drivers/: drv_gd25qxx.c drv_gd30ad3344.c drv_oled.c drv_oled_font.c
  group MIDDLEWARE
    ./middleware/: ringbuf.c crc16.c frame_parser.c
  group APP
    ./app/: app_tasks.c task_key.c task_led.c task_log.c tasks.h task_uart.c task_oled.c task_adc.c app_protocol.c app_cmd.c app_adc.c app_power.c
  group USER
    ./USER/: gd32f4xx_it.c main.c
target APP_B (6220000::V6.22::ARMCLANG)
  device: GD32F470VE GigaDevice
  pack: GigaDevice.GD32F4xx_DFP.3.0.3
  cpu: IRAM(0x20000000,0x030000) IRAM2(0x10000000,0x010000) IROM(0x08029000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: APP_B +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F470,APP_SLOT_B
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8029000 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
